# Keil uVision project m0.uvprojx, settings and files
target sensor_ARM_M0_BMP280 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: m0 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F030,USE_STDPERIPH_DRIVER,
  c include: .\cmsis\Include;.\STM32F0xx_StdPeriph_Lib_V1.5.0\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\cmsis;.\user;.\HW_DRIVER;.\filter
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group user
    ./user/: main.c stm32f0xx_it.c main_test.c
  group cmsis
    ./cmsis/Source/Templates/arm/: startup_stm32f0xx.s startup_stm32f0xx_ld.s startup_stm32f030.s startup_stm32f030xc.s startup_stm32f031.s startup_stm32f042.s startup_stm32f051.s startup_stm32f070x6.s startup_stm32f070xb.s startup_stm32f072.s startup_stm32f091.s
    ./cmsis/Source/Templates/: system_stm32f0xx.c
  group std_lib
    ./STM32F0xx_StdPeriph_Lib_V1.5.0/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group APP
    ./user/: bmp280.c bmp280_support.c
  group HW_DRIVER
    ./HW_DRIVER/: BMP085.c delay.c i2c_soft.c led.c my_bmp180.c msb.c my_bmp180_v2.c
  group EKF
    ./filter/: tinyekf.c my_kf.c
